# IAR project libemail.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; ../; ../../../../simplelink/; ../../../../simplelink/source; ../../../../simplelink/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libmail.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: base64.c email.c
