<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\cc3200_gizwits.ewp</path>
  </project>
  <batchBuild/>
</workspace>


