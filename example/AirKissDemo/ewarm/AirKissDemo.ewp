# IAR project AirKissDemo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../airkiss_ti_cc3200_cm4_1.0.0.22585
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AirKissDemo.bin
  ILINK.IlinkOutputFile: AirKissDemo.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/NON_OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../airkiss_ti_cc3200_cm4_1.0.0.22585/libairkiss.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: airkiss.c main.c pinmux.c scan.c
    ../../common/: startup_ewarm.c uart_if.c
