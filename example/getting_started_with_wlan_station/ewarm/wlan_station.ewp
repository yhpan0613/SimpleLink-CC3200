# IAR project wlan_station.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../oslib/; ../../../third_party/FreeRTOS/source/; ../../../third_party/FreeRTOS/source/include/; ../../../third_party/FreeRTOS/source/portable/IAR/ARM_CM4/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../gagent/include; ../gagent/cloud/inc; ../gagent/lan/inc; ../gagent/local/inc; ../gagent/iof; ../gagent/arch/CC3200; ../gagent/arch/CC3200/net; ../gagent/arch/CC3200/hal_serial
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wlan_station.bin
  ILINK.IlinkOutputFile: wlan_station.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../common/: gpio_if.c startup_ewarm.c uart_if.c
    ../: main.c pinmux.c
  group gagent
    ../gagent/: gagent.c gagent_netevent.c
  group gagent/arch/CC3200
    ../gagent/arch/CC3200/: adapter_cc3200.c
    ../gagent/arch/CC3200/hal_serial/: hal_uart.c
    ../gagent/arch/CC3200/net/: netevent.c
  group gagent/cloud
    ../gagent/cloud/src/: cloud.c http.c mqttbase.c mqttlib.c mqttxpg.c
  group gagent/core
    ../gagent/core/: user_misc.c utilcoding.c
  group gagent/lan
    ../gagent/lan/src/: lan.c lantcp.c lanudp.c webconfig.c
  group gagent/local
    ../gagent/local/src/: hal_receive.c local.c mcu_common.c
