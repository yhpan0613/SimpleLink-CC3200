# IAR project simplelink.ewp, settings and files
configuration OS (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SL_FULL; ewarm; SL_PLATFORM_MULTI_THREADED
  ICCARM.CCIncludePath2: ../; ../source/; ../include/; ../../inc/; ../../driverlib; ../../oslib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simplelink.bin
  ILINK.IlinkOutputFile: simplelink.out
configuration NON_OS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SL_FULL; ewarm
  ICCARM.CCIncludePath2: ../; ../source/; ../include/; ../../inc/; ../../driverlib
  ICCARM.CCOptLevel: 1
configuration PM_Framework (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SL_FULL; ewarm; SL_PLATFORM_MULTI_THREADED; DISABLE_DEBUGGER_RECONNECT
  ICCARM.CCIncludePath2: ../; ../source/; ../include/; ../../inc/; ../../driverlib; ../../oslib; ../../middleware/driver/; ../../middleware/driver/hal/; ../../middleware/framework/pm/
configuration NON_OS_PM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SL_FULL; ewarm; NON_OS_PM; DISABLE_DEBUGGER_RECONNECT
  ICCARM.CCIncludePath2: as above
  group (top)
    ../: cc_pal.c cc_pal_pm.c
    ../source/: device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c wlan.c
